## drivers/ndckpt/Kconfig
```kconfig
config NDCKPT
tristate "In-kernel Checkpointing with NVDIMM"
depends on LIBNVDIMM
default m
help
ndckpt app
```
